# Copyright (C) 2026 Advanced Micro Devices, Inc.
# SPDX-License-Identifier: BSD-3-Clause

FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += " file://zocl-allocator.patch"
